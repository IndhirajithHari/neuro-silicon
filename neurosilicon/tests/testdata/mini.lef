VERSION 5.8 ;
MACRO FAKE_BUF
  SIZE 1.0 BY 2.0 ;
END FAKE_BUF
MACRO FAKE_INV
  SIZE 1.0 BY 2.0 ;
END FAKE_INV
END LIBRARY
